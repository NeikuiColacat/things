ORG 0000H
AJMP MAIN
ORG 0003H
AJMP MINT0
ORG 0013H
AJMP MINT1


MINT0:
	MOV P1,#0DEH;保持红灯
	RETI
;深夜模式，黄灯闪烁
MINT1:
	SETB P1.0
	SETB P1.2
	SETB P1.5
	SETB P1.7
	
	CPL P1.1
	CPL P1.6
	ACALL DELAY1
	RETI
	
ORG 0030H
;循环调用
MAIN:
	SETB EA
	SETB EX0
	SETB EX1
	CLR IT0
	CLR IT1
	SETB PX0
	MOV P1,#0FFH
	
	ACALL ST1
	ACALL ST2
	ACALL ST3
	ACALL ST4
	AJMP MAIN
;四个状态，分别对应四个函数
ST1:
	MOV P1,#7EH
	ACALL DELAY2
	RET
ST2:
	MOV P1,#0BEH
	MOV R3,#6
	LST2:
	ACALL DELAY
	CPL P1.6
	DJNZ R3 , LST2
	RET
ST3:
	MOV P1,#0DBH
	ACALL DELAY2
	RET
ST4:
	MOV P1,#0DDH
	MOV R3,#6
	LST4:
	ACALL DELAY
	CPL P1.1
	DJNZ R3 , LST4
	RET
;延时函数
DELAY:
	MOV R0,#0FFH
	LP1:
	MOV R1,#0FFH
	DJNZ R1,$
	DJNZ R0,LP1
	RET

DELAY1:
	MOV R5,#0FFH
	LP5:
	MOV R6,#0FFH
	DJNZ R6,$
	DJNZ R5,LP5
	RET
	
DELAY2:
	MOV R0,#100
	LP3:
	MOV R1,#250
	LP4:
	MOV R2,#50
	DJNZ R2,$
	DJNZ R1,LP4
	DJNZ R0,LP3
	RET
	
END
