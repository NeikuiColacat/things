ORG 0000H
AJMP INIT
ORG 000BH
AJMP INTR
ORG 0030H

INTR:
	MOV TL0 , #78H
	MOV TH0 , #0ECH
	DJNZ R0 , RETT0
	CPL P2.7
	MOV R0 , #100
	RETT0:RETI

INIT:
	MOV DPTR , #TABLE
	MOV TMOD , #51H
	SETB EA
	SETB ET0
	MOV TL0 , #78H
	MOV TH0 , #0ECH
	MOV R0 , #100
	SETB TR0
	SETB TR1

MAIN:
	ACALL DISPLAY
	AJMP MAIN
DISPLAY:
	MOV R4 , TL1
	CJNE R4, #100 , NEXT
	MOV TL1 , #0
	NEXT:
	MOV A , TL1 
	MOV B , #10
	DIV AB
	
	SETB P2.0
	MOVC A , @A + DPTR
	MOV P0 , A
	ACALL DELAY
	CLR P2.0
	
	SETB P2.1
	MOV A , B
	MOVC A , @A + DPTR
	MOV P0 , A
	ACALL DELAY
	CLR P2.1
	RET

TABLE:
	DB 0C0H,0F9H,0A4H,0B0H
	DB 99H,92H,82H,0F8H
	DB 80H,90H,88H,83H
	DB 0C6H,0A1H,86H,8EH

DELAY:
	MOV R2 , #5
	TAG:
	MOV R3 , #100
	DJNZ R3 , $
	DJNZ R2 , TAG
	RET
END
	

	
	