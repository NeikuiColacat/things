ORG 0000H
AJMP MAIN
ORG 0030H
	MAIN:
	MOV P3,#0FFH
	MOV A,#0FEH
	CHK:
	JB P3.0,BLINK
	AJMP CHK
	
	BLINK:
	JB P3.1,RIGHT
	
	LEFT:
	RL A
	AJMP OP
	RIGHT:
	RR A
	OP:
	MOV P2 , A
	ACALL DELAY
	AJMP CHK
	
	DELAY: 
	MOV R0 , #100
	LOOP1:
	MOV R1 , #100
	LOOP2:
	MOV R2 ,#50
	DJNZ R2,$
	DJNZ R1,LOOP2
	DJNZ R0,LOOP1
	RET
	
END
	
	
